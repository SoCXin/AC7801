# Keil uVision project AC780x_App.uvprojx, settings and files
target AC780x_App (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: AC78013FDLA AutoChips
  pack: AutoChips.AC780x_DFP.1.0.1
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: AC780x_App
  AfterMake: fromelf.exe --bin -o AC780x_App.bin ./Objects/AC780x_App.axf
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: ..\App\os;..\SDK
  memory RVCT4: ROM 0x8006000 size 0x19000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ../App/: main.c
  group Os
    ../App/os/: OS_HW.c OS_SW.c tasks.c
  group Sdk
    ../SDK/: sdk_can.c sdk_flash.c sdk_interruptTask.c sdk_system.c
software components: CMSIS:CORE 5.0.1, Board Support:AC780x Development Kit:Debug 1.0.0, Device:ATC Drivers:CAN 1.0.0, Device:ATC Drivers:CKGEN 1.0.0, Device:ATC Drivers:DMA 1.0.0, Device:ATC Drivers:GPIO 1.0.0, Device:ATC Drivers:SPM 1.0.0, Device:ATC Drivers:TIMER 1.0.0, Device:ATC Drivers:UART 1.0.0, Device:ATC Drivers:eFlash 1.0.0, Device:Startup 1.0.0
