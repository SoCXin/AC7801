# Keil uVision project winwdg_2sto5s_timeout.uvprojx, settings and files
target winwdg_2sto5s_timeout (5060422::V5.06 update 4 (build 422)::ARMCC)
  device: AC78013FDLA AutoChips
  pack: AutoChips.AC780x_DFP.1.0.0
  cpu: IRAM(0x20000000,0x5000) IROM(0x08000000,0x20000) CPUTYPE("Cortex-M0+") CLOCK(12000000) ELITTLE
  output: winwdg_2sto5s_timeout
  c flags: Optim=1 OneElfS=1 uC99=1 v6Lang=1 v6LangP=1 wLevel=2
  c include: .\User
  memory RVCT4: ROM 0x8000000 size 0x20000
  memory RVCT9: RAM 0x20000000 size 0x5000
  group User
    ./User/: mian.c winwdg_2sto5s_timeout.c
software components: CMSIS:CORE 5.0.1, Device:ATC Drivers:CKGEN 1.0.0, Device:ATC Drivers:GPIO 1.0.0, Device:ATC Drivers:SPM 1.0.0, Device:ATC Drivers:WDG 1.0.0, Device:Startup 1.0.0
